# IAR project Backup of RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; STM32F10xFWLib\inc; ..\..\Source\include; ..\common\include; board\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: RTOSDemo.hex
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    board/: function.c keypad.c lapis.c pos.c process.c TextLcd.c utility.c
  group Demo files
    ./: main.c stm32f10x_it.c
  group FreeRTOS files
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group ST Library
    STM32F10xFWLib/src/: cortexm3_macro.s stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_usart.c
    ../Common/drivers/ST/STM32F10xFWLib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_tim.c
  group System files
    ./: stm32f10x_vector.c
